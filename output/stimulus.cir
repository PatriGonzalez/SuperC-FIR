*- INFO: The inputs in race logic
Vs n1 0 pwl 0 0 7866.22p 0 7916.22p 50m 7966.22p 0
Rs n1 n2  100
Xs_sfq n2 nX0 VCC dcsfq

Vs1 n3 0 pwl 0 0 5295.14p 0 5345.14p 50m 5395.14p 0
Rs1 n3 n4  100
Xs1_sfq n4 nX1 VCC dcsfq

Vs2 n5 0 pwl 0 0 6242.38p 0 6292.38p 50m 6342.38p 0
Rs2 n5 n6  100
Xs2_sfq n6 nX2 VCC dcsfq

Vs3 n7 0 pwl 0 0 16120.74p 0 16170.74p 50m 16220.74p 0
Rs3 n7 n8  100
Xs3_sfq n8 nX3 VCC dcsfq

*- INFO: Coefficients
**-INFO: Tap: 0
  X1 SET_COEF SET_COEF00s SET_COEF00 VCC split
  X2 RST_COEF RST_COEF00s RST_COEF00 VCC split
  X3 nP0a nP00s nP00 VCC split
  X4 SET_COEF00 NCC00 RST_COEF00 nP00 n00 VCC ndro_il

  X5 SET_COEF00s SET_COEF01s SET_COEF01 VCC split
  X6 RST_COEF00s RST_COEF01s RST_COEF01 VCC split
  X7 nP1a nP01s nP01 VCC split
  X8 SET_COEF01 NCC01 RST_COEF01 nP01 n01 VCC ndro_il

  X9 SET_COEF01s SET_COEF02s SET_COEF02 VCC split
  X10 RST_COEF01s RST_COEF02s RST_COEF02 VCC split
  X11 nP2a nP02s nP02 VCC split
  X12 0 NCC02 RST_COEF02 nP02 n02 VCC ndro_il

  X13 SET_COEF02s SET_COEF03s SET_COEF03 VCC split
  X14 RST_COEF02s RST_COEF03s RST_COEF03 VCC split
  X15 nP3a nP03s nP03 VCC split
  X16 0 NCC03 RST_COEF03 nP03 n03 VCC ndro_il

  X17 SET_COEF03s SET_COEF04s SET_COEF04 VCC split
  X18 RST_COEF03s RST_COEF04s RST_COEF04 VCC split
  X19 nP4a nP04s nP04 VCC split
  X20 0 NCC04 RST_COEF04 nP04 n04 VCC ndro_il

  X21 SET_COEF04s SET_COEF05s SET_COEF05 VCC split
  X22 RST_COEF04s RST_COEF05s RST_COEF05 VCC split
  X23 nP5a nP05s nP05 VCC split
  X24 SET_COEF05 NCC05 RST_COEF05 nP05 n05 VCC ndro_il

  X25 SET_COEF05s SET_COEF06s SET_COEF06 VCC split
  X26 RST_COEF05s RST_COEF06s RST_COEF06 VCC split
  X27 nP6a nP06s nP06 VCC split
  X28 SET_COEF06 NCC06 RST_COEF06 nP06 n06 VCC ndro_il

**-INFO: Tap: 1
  X29 SET_COEF06s SET_COEF10s SET_COEF10 VCC split
  X30 RST_COEF06s RST_COEF10s RST_COEF10 VCC split
  X31 nP00s nP10s nP10 VCC split
  X32 SET_COEF10 NCC10 RST_COEF10 nP10 n10 VCC ndro_il

  X33 SET_COEF10s SET_COEF11s SET_COEF11 VCC split
  X34 RST_COEF10s RST_COEF11s RST_COEF11 VCC split
  X35 nP01s nP11s nP11 VCC split
  X36 SET_COEF11 NCC11 RST_COEF11 nP11 n11 VCC ndro_il

  X37 SET_COEF11s SET_COEF12s SET_COEF12 VCC split
  X38 RST_COEF11s RST_COEF12s RST_COEF12 VCC split
  X39 nP02s nP12s nP12 VCC split
  X40 0 NCC12 RST_COEF12 nP12 n12 VCC ndro_il

  X41 SET_COEF12s SET_COEF13s SET_COEF13 VCC split
  X42 RST_COEF12s RST_COEF13s RST_COEF13 VCC split
  X43 nP03s nP13s nP13 VCC split
  X44 SET_COEF13 NCC13 RST_COEF13 nP13 n13 VCC ndro_il

  X45 SET_COEF13s SET_COEF14s SET_COEF14 VCC split
  X46 RST_COEF13s RST_COEF14s RST_COEF14 VCC split
  X47 nP04s nP14s nP14 VCC split
  X48 SET_COEF14 NCC14 RST_COEF14 nP14 n14 VCC ndro_il

  X49 SET_COEF14s SET_COEF15s SET_COEF15 VCC split
  X50 RST_COEF14s RST_COEF15s RST_COEF15 VCC split
  X51 nP05s nP15s nP15 VCC split
  X52 0 NCC15 RST_COEF15 nP15 n15 VCC ndro_il

  X53 SET_COEF15s SET_COEF16s SET_COEF16 VCC split
  X54 RST_COEF15s RST_COEF16s RST_COEF16 VCC split
  X55 nP06s nP16s nP16 VCC split
  X56 SET_COEF16 NCC16 RST_COEF16 nP16 n16 VCC ndro_il

**-INFO: Tap: 2
  X57 SET_COEF16s SET_COEF20s SET_COEF20 VCC split
  X58 RST_COEF16s RST_COEF20s RST_COEF20 VCC split
  X59 nP10s nP20s nP20 VCC split
  X60 SET_COEF20 NCC20 RST_COEF20 nP20 n20 VCC ndro_il

  X61 SET_COEF20s SET_COEF21s SET_COEF21 VCC split
  X62 RST_COEF20s RST_COEF21s RST_COEF21 VCC split
  X63 nP11s nP21s nP21 VCC split
  X64 SET_COEF21 NCC21 RST_COEF21 nP21 n21 VCC ndro_il

  X65 SET_COEF21s SET_COEF22s SET_COEF22 VCC split
  X66 RST_COEF21s RST_COEF22s RST_COEF22 VCC split
  X67 nP12s nP22s nP22 VCC split
  X68 SET_COEF22 NCC22 RST_COEF22 nP22 n22 VCC ndro_il

  X69 SET_COEF22s SET_COEF23s SET_COEF23 VCC split
  X70 RST_COEF22s RST_COEF23s RST_COEF23 VCC split
  X71 nP13s nP23s nP23 VCC split
  X72 SET_COEF23 NCC23 RST_COEF23 nP23 n23 VCC ndro_il

  X73 SET_COEF23s SET_COEF24s SET_COEF24 VCC split
  X74 RST_COEF23s RST_COEF24s RST_COEF24 VCC split
  X75 nP14s nP24s nP24 VCC split
  X76 0 NCC24 RST_COEF24 nP24 n24 VCC ndro_il

  X77 SET_COEF24s SET_COEF25s SET_COEF25 VCC split
  X78 RST_COEF24s RST_COEF25s RST_COEF25 VCC split
  X79 nP15s nP25s nP25 VCC split
  X80 SET_COEF25 NCC25 RST_COEF25 nP25 n25 VCC ndro_il

  X81 SET_COEF25s SET_COEF26s SET_COEF26 VCC split
  X82 RST_COEF25s RST_COEF26s RST_COEF26 VCC split
  X83 nP16s nP26s nP26 VCC split
  X84 SET_COEF26 NCC26 RST_COEF26 nP26 n26 VCC ndro_il

**-INFO: Tap: 3
  X85 SET_COEF26s SET_COEF30s SET_COEF30 VCC split
  X86 RST_COEF26s RST_COEF30s RST_COEF30 VCC split
  X87 nP20s nP30s nP30 VCC split
  X88 SET_COEF30 NCC30 RST_COEF30 nP30 n30 VCC ndro_il

  X89 SET_COEF30s SET_COEF31s SET_COEF31 VCC split
  X90 RST_COEF30s RST_COEF31s RST_COEF31 VCC split
  X91 nP21s nP31s nP31 VCC split
  X92 SET_COEF31 NCC31 RST_COEF31 nP31 n31 VCC ndro_il

  X93 SET_COEF31s SET_COEF32s SET_COEF32 VCC split
  X94 RST_COEF31s RST_COEF32s RST_COEF32 VCC split
  X95 nP22s nP32s nP32 VCC split
  X96 0 NCC32 RST_COEF32 nP32 n32 VCC ndro_il

  X97 SET_COEF32s SET_COEF33s SET_COEF33 VCC split
  X98 RST_COEF32s RST_COEF33s RST_COEF33 VCC split
  X99 nP23s nP33s nP33 VCC split
  X100 0 NCC33 RST_COEF33 nP33 n33 VCC ndro_il

  X101 SET_COEF33s SET_COEF34s SET_COEF34 VCC split
  X102 RST_COEF33s RST_COEF34s RST_COEF34 VCC split
  X103 nP24s nP34s nP34 VCC split
  X104 0 NCC34 RST_COEF34 nP34 n34 VCC ndro_il

  X105 SET_COEF34s SET_COEF35s SET_COEF35 VCC split
  X106 RST_COEF34s RST_COEF35s RST_COEF35 VCC split
  X107 nP25s nP35s nP35 VCC split
  X108 0 NCC35 RST_COEF35 nP35 n35 VCC ndro_il

  X109 SET_COEF35s SET_COEF36s SET_COEF36 VCC split
  X110 RST_COEF35s RST_COEF36s RST_COEF36 VCC split
  X111 nP26s nP36s nP36 VCC split
  X112 0 NCC36 RST_COEF36 nP36 n36 VCC ndro_il
